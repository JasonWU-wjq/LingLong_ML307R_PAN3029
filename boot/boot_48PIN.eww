<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\boot_48PIN.ewp</path>
    </project>
    <batchBuild/>
</workspace>
