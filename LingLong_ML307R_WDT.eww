<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\LingLong_ML307R_WDT.ewp</path>
    </project>
    <batchBuild/>
</workspace>
